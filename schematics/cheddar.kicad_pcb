# Repository tperale/cheddar

File README.md:

<h1 align="center">Cheddar</h1>
<h6 align="center">
  
</h6>
<p align="center">
<sup>
      <strong>Cheddar</strong> is a connected button based on the ESP8266.
</sup>
<br>

## What is this ?

Amazon created not a long time ago a connected button (called Dash button) that allows to make an order on Amazon just by pressing a single button facilitating the process of buying of household goods.
It didn't take a long time before hackers started appropriating the object and use it for their own purposes:

  * [Hacking Amazon’s $5 Dash Button to order Domino’s Pizza](https://medium.com/@brody_berson/hacking-amazon-s-5-dash-button-to-order-domino-s-pizza-9d19c9d04646)
  * [How To Use the Amazon Dash with IFTTT and Home Assistant](https://www.youtube.com/watch?v=qZpJ9W0wCks)

All that had to be done was to buy one, get the button ID through the Amazon app and encode that ID to _whatever_ was listening to the incoming query.
Amazon gave you a $5 connected piece of hardware, battery and case included that allowed you to do virtually anything with it.

As amazing as this might sound, the problems of those buttons are:

  * You need an amazon premium account to purchase them and get the button ID.
  * You can't directly program them, which makes complex queries more difficult to run and embedding sensors impossible.
  * You need a server running somewhere locally to listen to the incoming queries.
  * You can't wake it up from external events other than by pressing the button.

## What to do ?

Why not create our own open source "Amazon Dash button". It would also run on a battery, can be programmed and is Internet-connected.

Why not use an ESP8266 microcontroller for this purpose, it's used in a wide variety of projects, many frameworks are developed around it and it's also really cheap.

Powering an ESP8266 dev board (WEMOS D1, NodeMCU DevKit, Sparkfun ESP8266 Thing...) with a battery and waking it up when the button is pressed is quite a trivial problem and not fun. That's why I chose to create a PCB to host the ESP8266 module. Although it has some requirements:

  * Be able to program it and debug it from USB
  * Can run on batteries
  * Batteries should be rechargeable using the on board USB
  * It should be power efficient

## Datasheets

Schematic available [here](https://sendnu.de/f/f.php?h=1UXSZL2z&d=1).

## BOM

### Semiconductors

Ref | Qty | Value | Footprint
----|-----|-------|---------------
U2 | 1 | ch340g | SO-16-N
U3 | 1 | MCP73831 | SOT23-5
U4 | 1 | HT7333 | SOT89
U1 | 1 | ESP-12E | ESP-12E_SMD

### Capacitors

Ref | Qty | Value | Footprint
----|-----|-------|---------------
C2, C3 | 2 | 22pF | 1206
C4, C8 | 2 | 100nF | 1206
C5 | 1 | 10nF | 1206
C6 | 1 | 22nF | 1206
C7 | 1 | 1uF  | 1206
C9, C1 | 2 | 220uF | 1206

### Transistors

Ref | Qty | Value | Footprint
----|-----|-------|---------------
Q1  | 1   | MOSFET_PCH | SOT23-3

### Resistors

Ref | Qty | Value | Footprint
----|-----|-------|---------------
R1 | 1 | 470R | 1206
R3, R5, R6, R7, R8 | 5 | 10kR | 1206
R9 | 1 | 100kR | 1206

### Crystals

Ref | Qty | Value | Footprint
----|-----|-------|---------------
Y1 | 1 | 12Mhz | Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering

### Diodes

Ref | Qty | Value | Footprint
----|-----|-------|---------------
D1 | 1 | GREEN | 1206
D4 | 1 | Schottky | SOD-523

### Connectors

Ref | Qty | Footprint
----|-----|---------------
J1 | 1 | Connectors_JST:JST_SH_SM02B-SRSS-TB_02x1.00mm_Angled
J2 | 1 | Pin_Headers:Pin_Header_Straight_1x02_Pitch2.54mm_SMD_Pin1Left
J3 | 1 | Connectors_USB:USB_Micro-B_Molex_47346-0001
J5 J4 | 2 | Pin_Headers:Pin_Header_Straight_1x08_Pitch2.54mm

### Switch

Ref | Qty | Footprint
----|-----|---------------
SW1 | 1 | Buttons_Switches_SMD:SW_DIP_x1_W5.08mm_Slide_Copal_CHS-A

## References

* [Long lasting DIY "Amazon Dash Button" using an ESP8266](https://www.youtube.com/watch?v=nbMfb0dIvYc&t=307s)
* [Cheap IFTTT Button with spare ESP-01 finished](https://www.youtube.com/watch?v=6JD2RMDM88Y)
* [How to properly power the ESP8266 modules](https://www.youtube.com/watch?v=wf_msvWv1jk)
* [ESP8266 Wiki - Boot Mode Selection](https://github.com/espressif/esptool/wiki/ESP8266-Boot-Mode-Selection)
* [CH340G - USB-UART Chip](http://www.sunrom.com/p/ch340g)

## Useful links / similar projects

* [1btn](https://github.com/knewron-technologies/1btn)
* [goButton](https://www.kickstarter.com/projects/805606890/gobutton-simple-wi-fi-connected-smart-button-for-e/description)
* [ESP8266-Dash-Button](https://github.com/DeqingSun/ESP8266-Dash-Button)

## Collaborators

* [carlosgeos](https://github.com/carlosgeos)

## License

[Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)](https://creativecommons.org/licenses/by-sa/4.0/)

## KiCad design schematics/cheddar.kicad_pcb

Board: 2 copper layers, 43.0 x 26.0 mm, 26 parts (16 on the bottom side), 15 nets.

Parts:
BAT_CONN: BATT_CONN; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C1, C6: 100nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C2: 10nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3: 22nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4, C5: 22pF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C7: 1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C8, C9: 220uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: GREEN; LED_1206_3216Metric
J1: USB_OTG; USB_Micro-B-custom
Q1: MOSFET_PCH; SOT-23_Handsoldering
R1, R2, R5, R6, R7: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3: 470; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 100k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
TRIG: EXTERNAL_TRIGGER; PinHeader_1x02_P2.54mm_Vertical
TRIG_SW: SW_Push; SW_SPST_REED_CT05-XXXX-G1
U1: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U2: MCP73831; SOT-23-5_HandSoldering
U4: HT7333; SOT-89-3_Handsoldering
Y1: 12Mhz; CRYSTAL-SMD-3.2X2.5MM

Connections:
+3V3: C6.2, C9.1, R2.1, R6.2, R7.2, U4.2
+5V: C1.2, C2.2, D1.2, J1.1, Q1.1, R4.1, U1.16, U2.4
/CH_PD: R6.1, U1.14
/D+: J1.3, U1.5
/D-: J1.2, U1.6
/GPIO16: R2.2, TRIG.2, TRIG_SW.2
/XI: C4.1, U1.7, Y1.1
/XO: C5.1, U1.8, Y1.2
GND: BAT_CONN.1, C1.1, C2.1, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, J1.5, J1.6, R1.2, R4.2, R5.2, TRIG.1, TRIG_SW.1, U1.1, U2.2, U4.1
unnamed: C3.1, U1.4
unnamed: BAT_CONN.2, C7.2, Q1.2, U2.3
unnamed: C8.1, Q1.3, U4.3
unnamed: D1.1, R3.2
unnamed: R1.1, U2.5
unnamed: R3.1, U2.1

## KiCad design schematics/dash.kicad_pcb

Parts:
C1, C9: 220uF; C_1206_HandSoldering
C2, C3: 22pF; C_1206_HandSoldering
C4, C8: 100nF; C_1206_HandSoldering
C5: 10nF; C_1206_HandSoldering
C6: 22nF; C_1206_HandSoldering
C7: 1uF; C_1206_HandSoldering
D1: GREEN; LED_1206
D4: D_Schottky; SOD-523
J1: BATT_CONN; JST_SH_SM02B-SRSS-TB_02x1.00mm_Angled
J2: EXTERNAL_TRIGGER; Pin_Header_Straight_1x02_Pitch2.54mm_SMD_Pin1Left
J3: USB_OTG; USB_Micro-B-custom
J4, J5: Conn_01x08; Pin_Header_Straight_1x08_Pitch2.54mm
Q1: MOSFET_PCH; SOT23-3
R2: 470; R_1206_HandSoldering
R3, R5, R6, R7, R8: 10k; R_1206_HandSoldering
R9: 100k; R_1206_HandSoldering
SW1: SW_Push; SW_DIP_x1_W5.9mm_Slide_Copal_CVS
U1: ESP-12E; ESP-12E_SMD
U2: ch340g; SO-16-N
U3: MCP73831; SOT23-5
U4: HT7333; SOT89
URLAB-LOGO1: logo; urlab
Y1: 12Mhz; Crystal_SMD_5032_4Pads

Connections:
+3V3: C8.2, C9.1, J4.1, R5.1, R6.2, R8.2, U1.8 (VCC), U4.3 (VOUT)
+5V: C4.2, C5.2, D1.2 (A), D4.2 (A), J3.1 (VBUS), Q1.1 (G), R9.1, U2.16 (VCC), U3.4 (VIN)
/ADC: J4.7, U1.2 (ADC)
/CH_PD: J4.6, R6.1, U1.3 (CH_PD), U2.14 (RTS)
/D+: J3.3 (D+), U2.5 (D+)
/D-: J3.2 (D-), U2.6 (D-)
/GPIO0: J5.5, U1.12 (GPIO0), U2.13 (DTR)
/GPIO2: J5.6, R8.1, U1.11 (GPIO2)
/GPIO4: J5.4, U1.13 (GPIO4)
/GPIO5: J5.3, U1.14 (GPIO5)
/GPIO12: J4.3, U1.6 (GPIO12)
/GPIO13: J4.2, U1.7 (GPIO13)
/GPIO14: J4.4, U1.5 (GPIO14)
/GPIO15: J5.7, R7.1, U1.10 (GPIO15)
/GPIO16: J2.2, J4.5, J4.8, R5.2, SW1.2, U1.1 (REST), U1.4 (GPIO16)
/RXD: J5.2, U1.15 (RXD), U2.2 (TXD)
/TXD: J5.1, U1.16 (TXD), U2.3 (RXD)
/XI: C2.1, U2.7 (XI), Y1.1
/XO: C3.1, U2.8 (XO), Y1.2
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.1, C8.1, C9.2, J1.1, J2.1, J3.5 (GND), J3.6 (Shield), J5.8, R3.1, R7.2, R9.2, SW1.1, U1.9 (GND), U2.1 (GND), U3.2 (VSS), U4.1 (GND)
unnamed: C1.1, D4.1 (K), Q1.2 (S), U4.2 (VIN)
unnamed: C6.1, U2.4 (V3)
unnamed: C7.2, J1.2, Q1.3 (D), U3.3 (VBAT)
unnamed: D1.1 (K), R2.2
unnamed: R2.1, U3.1 (STAT)
unnamed: R3.2, U3.5 (PROG)

Board: 2 copper layers, 43.0 x 26.0 mm, 31 parts (19 on the bottom side), 26 nets.

## Commit log

2017-07-11 [add] Correction on boot mode pins
2017-07-12 [enh] More context on the README.md
2017-07-15 add libraries to project and link symbols with footprints
2017-07-15 fewer libs for tperale
2017-08-03 [enh] Fix pin mode (output/input)
2017-08-03 [enh] Better power port placement with fixed pin mode for ICs
2017-08-03 [fix] schematics gnd pins
2017-08-03 [enh] VSS connected directly to the battery
2017-08-05 [add] Shitty design to start with
2017-08-07 [enh] Change crystal placement and size
2017-08-07 [add] TX/RX wiring to the ESP-12
2017-08-07 [fix] Correct wiring
2017-08-07 [fix] Last fixes
2017-08-07 [add] Signature because fun
2017-08-07 [fix] Fill the zone correctly
2017-08-08 [fix] upgrade components to match our needs
2017-09-17 [fix] Global dependencies to local dependencies (no more path problem)
2017-09-17 [enh] Remove useless solder pads to have more room for the components
2017-09-22 [fix] Relative path for the ESP-12 component
2017-09-22 [fix] 3DShapes names
2017-09-23 [enh] Change capacitor value to match ceramic capacitor availability
2017-09-24 [enh] Redesigned project to take less space
2017-09-24 [fix] unconnected
2017-09-24 [fix] Track near pad
2017-09-24 add copper cutout under antenna
    https://electronics.stackexchange.com/questions/294165/ground-pour-under-esp8266-12-e
2017-09-25 [enh] Reduce the PCB size
2017-09-25 [fix] various things
2017-09-27 [enh] No pcb under the antenna to ensure good signal
2017-09-27 [add] Pinout
2017-09-28 bigger board
    - bigger button
    - labeled pinouts
    - battery connector: JST XH
2017-09-29 [enh] Add 3d models + better external trigger pad
2017-09-29 [fix] Right led footprint
2017-10-02 Update README.md
    Change description link
2017-10-02 [fix] Change crystal footprint to match availability
2017-10-02 [add] Forgot to update sch
2017-10-06 [enh] More infos on component + title block parameters
2017-10-06 Add BOM to README
2017-10-20 [add] Link to cheap components
2017-11-08 [rm] Indication on header pins
2017-11-08 [add] Link to ebay
2017-11-08 [add] Link to buy switch on ebay
2017-11-12 [chg] License to a hardware license
2017-11-18 [enh] Changed pcb size
2017-11-23 [add] Dimensions to pcb layout
2017-11-23 [enh] Do not include gerbers
2017-12-09 [fix] Better re-read those datasheets, wrong HT7333 pad mapping on the pcb
2017-12-14 [fix] Change footprints to match component buyed
2018-02-08 load sharing (USB <-> battery), change to MCP73831
    add all lib dependencies locally
    restructure dirs
    less vias in pads !
    change top copper pour to 5V, not 3,3V
    type fottprint in readme
2018-02-09 finish routing
2018-02-09 swap USB connector for a THT one
2018-02-23 change USB connector to custom
    add URLAB logo
2018-02-23 modify schottky diode footprint to SOD523
2018-02-25 fix some typos README.md
2018-03-20 correct crystal footprint. fixes #6
    bigger button footprint
    EXTERNAL_TRIGGER is now through hole
    some re-routing
2019-03-06 symbol remaps (for KiCad version 5)
2019-03-07 update README.md, more symbol remapping for KiCAD version 5
2019-03-07 cleanup project, rename dash->cheddar
2019-03-07 remove rescue symbol table, symbols have to be remapped manually
2019-03-07 add symbols to schematic
    remove redundant symbol libs (KiCAD version 5 has them already)
2019-03-07 fix #8, all components connected
2019-03-08 replace all footprints with standard lib ones
    remove unnecessary custom libs
2019-03-30 Reestructure board
2019-04-04 Routed new PCB
2019-04-04 Remove useless labeling
2019-04-04 [enh] better routing
